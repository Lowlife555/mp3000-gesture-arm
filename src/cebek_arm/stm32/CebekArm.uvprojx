# Keil uVision project CebekArm.uvprojx, settings and files
target CebekArm (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CebekArm +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32L476xx
  c include: .\cmsis;.
  asm define: STM32L476xx
  asm include: .\cmsis;.
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Startup
    ./: startup_stm32l476xx.s
  group Core
    ./: system.c main.c clock.c delay.c uart2.c
  group Drivers
    ./: lcd.c keys.c ui.c arm.c
  group Headers
    ./: board_pins.h font_data.h
